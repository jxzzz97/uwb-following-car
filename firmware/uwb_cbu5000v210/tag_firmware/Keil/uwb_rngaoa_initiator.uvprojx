# Keil uVision project uwb_rngaoa_initiator.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: CBU5000V210_DSP_FP Chipsbank
  pack: Keil.CBU5000V210_DFP.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x0,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: CBU5000V210 +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: UWB_ANTENNA_TYPE_CONFIG=DEF_ANTENNA_TYPE_TRIANGLE_UP
  c misc: -Wno-padded -Wno-declaration-after-statement -Wno-covered-switch-default -Wno-c11-extensions -Wno-format-nonliteral -Wno-gnu-binary-literal -Wno-overlength-strings -Wno-incompatible-pointer-types-discards-qualifiers -Wno-unused-parameter -Wno-unused-variable -Wno-unused-function -Wno-unused-but-set-parameter -Wno-unused-but-set-variable -Wno-cast-qual -Wno-missing-variable-declarations -Wno-strict-prototypes -Wno-undef -Wno-missing-noreturn -Wno-implicit-float-conversion -Wno-missing-prototypes -Wno-zero-length-array -Wno-extra-semi -Wno-variadic-macros -Wno-extra-semi-stmt -Wno-macro-redefined
  c include: ..\App;..\..\shared_sdk\External\FreeRTOS\Source\include;..\..\shared_sdk\External\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\shared_sdk\External\LibCRC\include;..\..\shared_sdk\Components\SharedUtils;..\..\shared_sdk\Components\DriverCpu\Inc;..\..\shared_sdk\Components\ArmCore\CMSIS_5.8.0\Core\Include;..\..\shared_sdk\Components\ArmCore;..\..\shared_sdk\Components\DriverUwb;..\..\shared_sdk\Components\Configuration;..\..\shared_sdk\Components\Midlayer\Flash;..\..\shared_sdk\Components\Midlayer\SleepDeepSleep;..\..\shared_sdk\Components\Midlayer\Aoa;..\..\shared_sdk\Components\Midlayer\System;..\..\shared_sdk\Components\Security;..\..\shared_sdk\Components\Algorithm;..\..\shared_sdk\Components\Application;..\..\shared_sdk\Components\DriverUwb\uwb_drivers;..\..\shared_sdk\Components\Midlayer\UwbFramework
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0xc00000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\ARMCM33_DSP_FP\ARMCM33_ac6.sct
  group APP_CPU
    ../App/: main.c
    ../../shared_sdk/Components/Application/: app_uart.c
  group APP_UWB
    ../App/: AppUwbRngAoa.c
  group Midlayer
    ../../shared_sdk/Components/Midlayer/SleepDeepSleep/: CB_SleepDeepSleep.c
    ../../shared_sdk/Components/Midlayer/System/: CB_system.c CB_uwbpackettemplate.c
    ../../shared_sdk/Components/Midlayer/UwbFramework/: CB_uwbframework.c
  group DriverCPU
    ../../shared_sdk/Components/DriverCpu/Src/: CB_gpio.c CB_iomux.c CB_scr.c CB_timer.c CB_Uart.c CB_wdt.c
  group DriverUWB
    ../../shared_sdk/Components/DriverUwb/: CB_uwb.c
  group FreeRTOS
    ../../shared_sdk/External/FreeRTOS/Source/: croutine.c event_groups.c freertos_evr.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../shared_sdk/External/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../shared_sdk/External/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group SharedUtils
    ../../shared_sdk/Components/SharedUtils/: NonLIB_sharedUtils.c
  group Scheduler
    ../App/: TaskHandler.c
  group LIB
    ../../shared_sdk/Libs/CB_Lib/: CBU5000V210_UWB_LIB.lib
  group memory map
    ./Listings/: CBU5000V210.map
  group Device
    ./ARMCM33_DSP_FP/: ARMCM33_ac6.sct
    ../../shared_sdk/Components/ArmCore/Device/ARMCM33_DSP_FP/: startup_ARMCM33.c system_ARMCM33.c
  group Bin
    ../../shared_sdk/Components/Lut/: lut_bin.s
